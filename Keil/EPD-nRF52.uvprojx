# Keil uVision project EPD-nRF52.uvprojx, settings and files
target nRF52811_xxAA (6110000::V6.11::.\ARMCLANG)
  device: nRF52811_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.40.3
  cpu: IRAM(0x20000000,0x00006000) IRAM2(0x00800000,0x00006000) IROM(0x00000000,0x00030000) CPUTYPE("Cortex-M4") DSP CLOCK(12000000) ELITTLE
  output: EPD-nRF52 +hex
  AfterMake: ..\tools\keil-postbuild.bat $L @L
  AfterMake: ..\keil5_disp_size_bar.exe
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 v6Lto=1
  c define: APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED CONFIG_GPIO_AS_PINRESET FLOAT_ABI_SOFT NRF52811_XXAA NRFX_COREDEP_DELAY_US_LOOP_CYCLES=3 NRF_DFU_SVCI_ENABLED NRF_DFU_TRANSPORT_BLE=1 NRF_SD_BLE_API_VERSION=7 S112 SOFTDEVICE_PRESENT FDS_ENABLED=0 NRF_FSTORAGE_ENABLED=0 __HEAP_SIZE=0 __STACK_SIZE=2048 NRF_STRERROR_ENABLED=0 NRF_LOG_ENABLED=0 BLE_LOG_REDIRECT_ALL_NRF_LOG=0 GFX_FIXED_BWR_PANEL=1 GFX_FIXED_FONT_DIRECTION_0=1 GUI_FIXED_PANEL_WIDTH=800 GUI_FIXED_PANEL_HEIGHT=480 CALENDAR_ANNOTATIONS_USE_NRF_CRITICAL=1
  c include: ..\;..\EPD\hal;..\EPD\driver;..\EPD\board;..\EPD\storage;..\EPD\app;..\EPD\service;..\GUI;..\SDK\17.1.0_ddde560;..\SDK\17.1.0_ddde560\components\ble\common;..\SDK\17.1.0_ddde560\components\ble\ble_advertising;..\SDK\17.1.0_ddde560\components\ble\nrf_ble_gatt;..\SDK\17.1.0_ddde560\components\ble\ble_services\ble_dfu;..\SDK\17.1.0_ddde560\components\libraries\atomic;..\SDK\17.1.0_ddde560\components\libraries\atomic_fifo;..\SDK\17.1.0_ddde560\components\libraries\atomic_flags;..\SDK\17.1.0_ddde560\components\libraries\balloc;..\SDK\17.1.0_ddde560\components\libraries\bootloader;..\SDK\17.1.0_ddde560\components\libraries\bootloader\ble_dfu;..\SDK\17.1.0_ddde560\components\libraries\bootloader\dfu;..\SDK\17.1.0_ddde560\components\libraries\delay;..\SDK\17.1.0_ddde560\components\libraries\fstorage;..\SDK\17.1.0_ddde560\components\libraries\fds;..\SDK\17.1.0_ddde560\components\libraries\experimental_section_vars;..\SDK\17.1.0_ddde560\components\libraries\log;..\SDK\17.1.0_ddde560\components\libraries\log\src;..\SDK\17.1.0_ddde560\components\libraries\memobj;..\SDK\17.1.0_ddde560\components\libraries\mutex;..\SDK\17.1.0_ddde560\components\libraries\pwr_mgmt;..\SDK\17.1.0_ddde560\components\libraries\ringbuf;..\SDK\17.1.0_ddde560\components\libraries\sortlist;..\SDK\17.1.0_ddde560\components\libraries\scheduler;..\SDK\17.1.0_ddde560\components\libraries\strerror;..\SDK\17.1.0_ddde560\components\libraries\svc;..\SDK\17.1.0_ddde560\components\libraries\timer;..\SDK\17.1.0_ddde560\components\libraries\util;..\SDK\17.1.0_ddde560\components\softdevice\common;..\SDK\17.1.0_ddde560\components\softdevice\s112\headers;..\SDK\17.1.0_ddde560\components\softdevice\s112\headers\nrf52;..\SDK\17.1.0_ddde560\components\toolchain\cmsis\include;..\SDK\17.1.0_ddde560\external\fprintf;..\SDK\17.1.0_ddde560\external\segger_rtt;..\SDK\17.1.0_ddde560\integration\nrfx;..\SDK\17.1.0_ddde560\integration\nrfx\legacy;..\SDK\17.1.0_ddde560\modules\nrfx;..\SDK\17.1.0_ddde560\modules\nrfx\mdk;..\SDK\17.1.0_ddde560\modules\nrfx\drivers\include;..\SDK\17.1.0_ddde560\modules\nrfx\hal;..\SystemView
  asm define: __HEAP_SIZE=0 __STACK_SIZE=2048 NRF52811_XXAA NRF_LOG_ENABLED=0 FDS_ENABLED=0 NRF_FSTORAGE_ENABLED=0
  asm include: ..\config;..\EPD\hal;..\EPD\driver;..\EPD\board;..\EPD\storage;..\EPD\app;..\EPD\service;..\GUI;..\SDK\17.1.0_ddde560;..\SDK\17.1.0_ddde560\components\ble\common;..\SDK\17.1.0_ddde560\components\ble\ble_advertising;..\SDK\17.1.0_ddde560\components\ble\nrf_ble_gatt;..\SDK\17.1.0_ddde560\components\libraries\atomic;..\SDK\17.1.0_ddde560\components\libraries\atomic_fifo;..\SDK\17.1.0_ddde560\components\libraries\atomic_flags;..\SDK\17.1.0_ddde560\components\libraries\balloc;..\SDK\17.1.0_ddde560\components\libraries\delay;..\SDK\17.1.0_ddde560\components\libraries\fstorage;..\SDK\17.1.0_ddde560\components\libraries\fds;..\SDK\17.1.0_ddde560\components\libraries\experimental_section_vars;..\SDK\17.1.0_ddde560\components\libraries\log;..\SDK\17.1.0_ddde560\components\libraries\log\src;..\SDK\17.1.0_ddde560\components\libraries\memobj;..\SDK\17.1.0_ddde560\components\libraries\mutex;..\SDK\17.1.0_ddde560\components\libraries\pwr_mgmt;..\SDK\17.1.0_ddde560\components\libraries\ringbuf;..\SDK\17.1.0_ddde560\components\libraries\sortlist;..\SDK\17.1.0_ddde560\components\libraries\scheduler;..\SDK\17.1.0_ddde560\components\libraries\strerror;..\SDK\17.1.0_ddde560\components\libraries\timer;..\SDK\17.1.0_ddde560\components\libraries\util;..\SDK\17.1.0_ddde560\components\softdevice\common;..\SDK\17.1.0_ddde560\components\softdevice\s112\headers;..\SDK\17.1.0_ddde560\components\softdevice\s112\headers\nrf52;..\SDK\17.1.0_ddde560\components\toolchain\cmsis\include;..\SDK\17.1.0_ddde560\external\fprintf;..\SDK\17.1.0_ddde560\external\segger_rtt;..\SDK\17.1.0_ddde560\integration\nrfx;..\SDK\17.1.0_ddde560\integration\nrfx\legacy;..\SDK\17.1.0_ddde560\modules\nrfx;..\SDK\17.1.0_ddde560\modules\nrfx\mdk;..\SDK\17.1.0_ddde560\modules\nrfx\drivers\include;..\SDK\17.1.0_ddde560\modules\nrfx\hal;..\SystemView
  library: MicroLIB
  memory RVCT4: ROM 0x19000 size 0xe000
  memory RVCT9: RAM 0x200022d8 size 0x3d28
  memory RVCT10: RAM 0x800000 size 0x6000
  scatter file: .\EPD-nRF52-ac6.sct
  link misc: --diag_suppress 6330 --diag_suppress 6314
  group App
    ../: main.c
    ../SDK/17.1.0_ddde560/: sdk_config.h
    ./: ac6_gnu_symbols.c
  group EPD
    ../EPD/board/: EPD_config.c
    ../EPD/service/: epd_advertising.c epd_rle.c EPD_service.c epd_service_display.c epd_service_cmd.c epd_service_control.c epd_service_transfer.c resource_protocol.c resource_transfer.c
    ../EPD/app/: calendar_annotations_tx.c epd_refresh_policy.c epd_clock_refresh.c calendar_annotations_store.c epd_resources.c
    ../EPD/hal/: fm25q04b.c EPD_driver.c
    ../EPD/driver/: UC8179.c epd_models.c
    ../EPD/storage/: resource_store.c resource_crc.c resource_crc_flash.c persistent_record.c font_store.c
  group GUI
    ../GUI/: GUI.c calendar_resources.c ui_resources.c todo_items.c calendar_annotations.c Lunar.c font_geometry.c fonts.c u8g2_font.c Adafruit_GFX.c
  group nRF_BLE
    ../SDK/17.1.0_ddde560/components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
    ../SDK/17.1.0_ddde560/components/ble/ble_advertising/: ble_advertising.c
    ../SDK/17.1.0_ddde560/components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
  group nRF_DFU
    ../SDK/17.1.0_ddde560/components/ble/ble_services/ble_dfu/: ble_dfu.c ble_dfu_unbonded.c
  group nRF_Drivers
    ../SDK/17.1.0_ddde560/integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_spi.c
    ../SDK/17.1.0_ddde560/modules/nrfx/soc/: nrfx_atomic.c
    ../SDK/17.1.0_ddde560/modules/nrfx/drivers/src/: nrfx_clock.c nrfx_spi.c nrfx_spim.c nrfx_wdt.c
    ../SDK/17.1.0_ddde560/modules/nrfx/drivers/src/prs/: nrfx_prs.c
  group nRF_Libraries
    ../SDK/17.1.0_ddde560/components/libraries/util/: app_error.c app_error_handler_gcc.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../SDK/17.1.0_ddde560/components/libraries/scheduler/: app_scheduler.c
    ../SDK/17.1.0_ddde560/components/libraries/timer/: app_timer2.c drv_rtc.c
    ../SDK/17.1.0_ddde560/components/libraries/atomic_fifo/: nrf_atfifo.c
    ../SDK/17.1.0_ddde560/components/libraries/atomic_flags/: nrf_atflags.c
    ../SDK/17.1.0_ddde560/components/libraries/atomic/: nrf_atomic.c
    ../SDK/17.1.0_ddde560/components/libraries/balloc/: nrf_balloc.c
    ../SDK/17.1.0_ddde560/components/libraries/bootloader/dfu/: nrf_dfu_svci.c
    ../SDK/17.1.0_ddde560/external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../SDK/17.1.0_ddde560/components/libraries/memobj/: nrf_memobj.c
    ../SDK/17.1.0_ddde560/components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../SDK/17.1.0_ddde560/components/libraries/ringbuf/: nrf_ringbuf.c
    ../SDK/17.1.0_ddde560/components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../SDK/17.1.0_ddde560/components/libraries/sortlist/: nrf_sortlist.c
    ../SDK/17.1.0_ddde560/components/libraries/strerror/: nrf_strerror.c
  group nRF_SoftDevice
    ../SDK/17.1.0_ddde560/components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
  group Startup
    ../SDK/17.1.0_ddde560/modules/nrfx/mdk/: arm_startup_nrf52811.s system_nrf52.c
